# Repository ch32-riscv-ug/CH32V20x

File README.md:

# CH32V20x

## Select chip

### CH32V203(EVT)

### CH32V208(EVT)

### CH32V205(EVT_205)

## KiCad design EVT/PUB/SCHPCB/CH32F&V208G-R0/CH32F&V208G-R0.kicad_pcb

Board: 2 copper layers, 60.0 x 80.0 mm, 51 parts (0 on the bottom side), 56 nets.

Parts:
C1: 10uF; 3216_C
C2: 10uF; 0603_C
C3, C7: 1uF; 0603_C
C4, C10, C18: 0.1uF; 0603_C
C13, C14: 12pF; 0603_C
C16, C17: 1.8pF; 0603_C
D1: power; 0603+
D3, D4: RED; 0603+
E1: ANTENNA; ANT-F-1-2.4G-1.6mmFR4
F1: 500mA; 0603
J1: TYPE-C-Receptacle-2.0
L1: 1.8nH; 0603
P1, P5: USB; USBAF
P2: HR911105A
P3: HEADER 4x2; IDC8-2.54mm
P4: HEADER 16; SIP16-2.54mm
P6: LINK; IDC10-2.54mm
P7: HEADER 15; SIP15-2.54mm
R1, R8, R9, R16, R17: 1K; 0603
R2, R7, R10, R20: 0Ω; 0603
R5, R6: NC(0R); 0603
R11, R12, R13, R14: 0R(NC); 0603
R15: 10K; 0603
R18, R19: NC(5.1K); 0603
R22: 4.7K; 0603
S1: SW SPDT; SW1
S2: KEY; SMD_6.1x3.65x2.5mm-KEY
S4: Download; SMD_6.1x3.65x2.5mm-KEY
U0: CH32V208G; QFN28_4x4
U1: 1117-3.3V; SOT-223
Y1: 32MHz; XT3225
Y2: 32768Hz; FC-135

Connections:
3V3: C2.1, P3.6, P7.2, R2.1
3V3S: D1.1, R2.2, R8.1, R9.1, R10.2, R16.1, R17.1, U1.2
+5V: F1.1, J1.A4, J1.B4, P1.1, P3.2, P3.4, P5.1, P6.9, P6.10
ANT: C17.2, L1.1, U0.22
BOOT0: R22.1, S4.2, U0.26
CC1: J1.A5, R19.1
CC2: J1.B5, R18.1
ELED1: P2.10, P7.6
ELED2: P2.11, P7.7
ERXN: P2.6, R13.2
ERXP: P2.3, R14.2
ETXN: P2.2, R11.2
ETXP: P2.1, R12.2
GND: C1.2, C2.2, C3.1, C4.2, C7.2, C10.1, C13.1, C14.1, C16.1, C17.1, C18.2, E1.0, J1.0, J1.A1, J1.B1, P1.0, P1.4, P3.1, P3.3, P3.5, P3.7, P4.3, P5.0, P5.4, P6.5, P6.6, P7.3, R1.1, R7.1, R15.1, R18.2, R19.2, U0.0, U1.1, Y1.2, Y1.4
KEY: P4.4, S2.1
LED1: D3.2, P7.4
LED2: D4.2, P7.5
NetC3_2: C3.2, P2.4, P2.5, R10.1
NetC16_2: C16.2, E1.1, L1.2
NetD1_2: D1.2, R1.2
NetD3_1: D3.1, R17.2
NetD4_1: D4.1, R16.2
NetF1_2: F1.2, S1.1
NetP2_8: P2.8, R7.2
NetP2_9: P2.9, R8.2
NetP2_12: P2.12, R9.2
NetP4_2: P4.2, R22.2
NetR15_2: R15.2, S2.2
PA0: P4.9, U0.5
PA1: P4.10, U0.6
PA2: P4.11, P6.2, U0.7
PA3: P4.12, P6.4, U0.8
PA4: P4.13, U0.9
PA5: P4.14, U0.10
PA6: P4.15, U0.11
PA7: P4.16, U0.12
PA11: P1.2, P7.11, U0.18
PA12: P1.3, P7.10, U0.19
PA13: P6.3, P7.9, U0.20
PA14: P6.1, P7.8, U0.23
PB6: J1.A7, J1.B7, P4.8, P5.2, U0.24
PB7: J1.A6, J1.B6, P4.7, P5.3, U0.25
PC6: P7.15, R14.1, U0.14
PC7: P7.14, R13.1, U0.15
PC8: P7.13, R12.1, U0.16
PC9: P7.12, R11.1, U0.17
PC14: P4.5, R5.1
PC15: P4.6, R6.1
V5V: C1.1, S1.2, U1.3
VDD: C4.1, C10.2, P3.8, P4.1, P6.7, P6.8, R20.1, S4.1, U0.13, U0.27
VDDA: C18.1, P7.1, R20.2, U0.4
VINTA: C7.1, U0.21
X32IN: C13.2, R5.2, U0.28, Y2.1
X32OUT: C14.2, R6.2, U0.1, Y2.2
XIN: U0.2, Y1.1
XOUT: U0.3, Y1.3

## KiCad design EVT/PUB/SCHPCB/CH32V203F8U6-R0/CH32V203F8U6-R0.kicad_pcb

Parts:
C12: 10uF; 3216_C
C13: 2.2uF; 0603_C
C18: 0.1uF; 0603_C
F1: 500mA; 0603
LED1: LED1 blue; 0603+
LED2: LED2 blue; 0603+
P1, P2: Header 7X2; IDC14-2.54mm
P4: 2HEAD; SIP2-2.54mm
P7: TYPE-C; TYPE-C-Receptacle-2.0
PWR: POWER red; 0603+
R1, R2, R3: 1K; 0603
R20, R21: NC(5.1K); 0603
R22, R23: 0R; 0603
S2: SW; SW1
U1: 6219P33M; SOT-23
U2: CH32V203F8U; QFN20_3x3

Connections:
+5V: P7.A4 (VBUS), P7.B4 (VBUS), S2.1
LED1: LED1.2 (K), P4.1
LED2: LED2.2 (K), P4.2
NetC12_1: C12.1, F1.2, U1.3 (Vin)
NetF1_1: F1.1, S2.3
NetLED1_1: LED1.1 (A), R2.2
NetLED2_1: LED2.1 (A), R3.2
NetP7_A5: P7.A5 (CC), R20.1
NetP7_B5: P7.B5 (CC), R21.1
NetPWR_1: PWR.1 (A), R1.1
PA0: P1.5, U2.1 (PA0/WKUP/ADC0)
PA1: P1.7, U2.2 (PA1/ADC1)
PA2: P1.9, U2.3 (PA2/ADC2/OP2O0)
PA3: P1.10, U2.4 (PA3/ADC3/OP1O0)
PA4: P1.11, U2.5 (PA4/ADC4/OP2O1)
PA5: P1.12, U2.6 (PA5/ADC5/OP2N1)
PA6: P2.12, U2.20 (PA6/ADC6/OP1N1/BKIN)
PA7: P1.13, U2.7 (PA7/ADC7/OP2P1/CH1N)
PA8: P2.9, U2.14 (PA8/CH1)
PA9: P2.10, U2.15 (PA9/CH2)
PA10: P2.11, U2.18 (PA10/CH3)
PA11: P7.A7 (D-), P7.B7 (D-), R22.1
PA12: P7.A6 (D+), P7.B6 (D+), R23.1
PA13/PA12: P1.8, R23.2, U2.16 (PA13/SWD/PA12/UDP)
PA14/PA11: P1.6, R22.2, U2.17 (PA14/SWC/PA11/UDM)
PB0: P2.3, U2.8 (PB0/ADC8/OP1P1/CH2N)
PB1: P2.4, U2.9 (PB1/ADC9/OP1O1/CH3N)
PB10: P2.5, U2.10 (PB10/OP2N0)
PB11: P2.6, U2.11 (PB11/OP1N0)
PB14: P2.7, U2.12 (PB14/OP2P0)
PB15: P2.8, U2.13 (PB15/OP1P0)
VCC: C13.2, C18.1, P1.1, P1.2, P2.13, P2.14, R1.2, R2.1, R3.1, U1.2 (Vout), U2.19 (VDD)

Notes on the sheet:
PIN
LED
POWER
CH32V203F8U_MINI
MCU
USB

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
Board: 2 copper layers, 36.6 x 45.8 mm, 21 parts (0 on the bottom side), 33 nets.

## KiCad design EVT/PUB/SCHPCB/CH32V203C8T6-R0/CH32V203C8T6-R0.kicad_pcb

Board: 2 copper layers, 45.8 x 56.0 mm, 36 parts (0 on the bottom side), 55 nets.

Parts:
C5, C6: 12pF; 0603_C
C7, C8: 22pF; 0603_C
C11, C14, C15, C16, C17, C18: 0.1uF; 0603_C
C12: 10uF; 3216_C
C13: 2.2uF; 0603_C
D1: POWER red; 0603+
D2: LED1; 0603+
D3: LED2; 0603+
F1: 500mA; 0603
P1: HEADER 12x2; IDC24-2.54MM
P2: HEADER 11x2; IDC22-2.54MM
P6, P8: USB_A; USBAF
P7: TYPE-C; TYPE-C-Receptacle-2.0
R1, R2, R3: 1K; 0603
R4, R5, R6: 10K; 0603
R7: 0Ω; 0603
R22, R23: NC(5.1K); 0603
S1: KEY; 贴片按键
S2: SW; KEY2
U1: 6219P33M; SOT-23
U2: CH32V203CxT; LQFP48
Y1: 8M; XT_AT49
Y2: 32.768k; FC-135

Connections:
+5V: P6.1, P7.A4, P7.B4, P8.1, S2.1
BOOT0: R5.1, U2.44
BOOT1: P1.13, R6.1, U2.20
GND: C5.2, C6.2, C7.1, C8.1, C11.1, C12.2, C13.2, C14.2, C15.2, C16.1, C17.1, C18.1, D1.2, P1.1, P1.22, P1.24, P2.6, P6.0, P6.4, P7.0, P7.A1, P7.B1, P8.0, P8.4, R22.2, R23.2, S1.2, U1.1, U2.8, U2.23, U2.35, U2.47, Y1.0
LED1: D2.2, P2.1
LED2: D3.2, P2.2
NRST: C11.2, P2.12, R4.1, S1.1, U2.7
NetD1_1: D1.1, R1.1
NetD2_1: D2.1, R2.2
NetD3_1: D3.1, R3.2
NetF1_1: F1.1, S2.3
NetP1_21: P1.21, R5.2
NetP1_23: P1.23, R6.2
NetP7_A5: P7.A5, R22.1
NetP7_B5: P7.B5, R23.1
PA0: P1.3, U2.10
PA1: P1.4, U2.11
PA2: P1.5, U2.12
PA3: P1.6, U2.13
PA4: P1.7, U2.14
PA5: P1.8, U2.15
PA6: P1.9, U2.16
PA7: P1.10, U2.17
PA8: P2.22, U2.29
PA9: P2.21, U2.30
PA10: P2.20, U2.31
PA11: P2.19, P6.2, U2.32
PA12: P2.18, P6.3, U2.33
PA13: P2.8, U2.34
PA14: P2.10, U2.37
PA15: P2.17, U2.38
PB0: P1.11, U2.18
PB1: P1.12, U2.19
PB3: P2.16, U2.39
PB4: P2.15, U2.40
PB5: P2.14, U2.41
PB6: P2.13, P7.A7, P7.B7, P8.2, U2.42
PB7: P2.11, P7.A6, P7.B6, P8.3, U2.43
PB8: P2.9, U2.45
PB9: P2.5, U2.46
PB10: P1.14, U2.21
PB11: P1.15, U2.22
PB12: P1.16, U2.25
PB13: P1.17, U2.26
PB14: P1.18, U2.27
PB15: P1.19, U2.28
PC13: P2.7, U2.2
PC14: C5.1, U2.3, Y2.1
PC15: C6.1, U2.4, Y2.2
PD0: C7.2, U2.5, Y1.2
PD1: C8.2, U2.6, Y1.1
V5V: C12.1, F1.2, U1.3
VBAT: C14.1, P2.3, U2.1
VCC: C13.1, C16.2, C17.2, C18.2, P1.2, P1.20, P2.4, R1.2, R2.1, R3.1, R4.2, R7.1, U1.2, U2.24, U2.36, U2.48
VDDA: C15.1, R7.2, U2.9

## KiCad design EVT/PUB/SCHPCB/CH32F&V208W-R0/CH32F&V208W-R0.kicad_pcb

Board: 2 copper layers, 86.5 x 95.0 mm, 65 parts (0 on the bottom side), 96 nets.

Parts:
C1: 10uF; 3216_C
C2: 10uF; 0603_C
C3, C7: 1uF; 0603_C
C4, C5, C6, C8, C9, C10, C15, C18: 0.1uF; 0603_C
C13, C14: 12pF; 0603_C
C16: 1.5pF; 0603_C
C17: 1pF; 0603_C
D1: power; 0603+
D3, D4: RED; 0603+
E1: ANTENNA; ANT-F-1-2.4G-1.6
F1: 500mA; 0603
J1: TYPE-C-Receptacle-2.0
J3: Header 21X2; IDC42-2.54mm
J4: Header 19X2; IDC38-2.54mm
J5, J8: Header 8; SIP8-2.54mm
J6: Header 6; SIP6-2.54MM
J7: Header 10; SIP10-2.54mm
L1: 1.8nH; 0603
P1, P5: USB; USBAF
P2: HR911105A
P3: HEADER 4x2; IDC8-2.54mm
P4: Psel; IDC6-2.54mm
P6: LINK; IDC10-2.54mm
R1, R8, R9, R16, R17: 1K; 0603
R2, R7, R10, R20: 0Ω; 0603
R3, R4, R5, R6, R11, R12, R13, R14: NC(0R); 0603
R15, R21, R22: 10K; 0603
R18, R19: NC(5.1K); 0603
S1: SW SPDT; KEY_B
S2: KEY; SMD_6.1x3.65x2.5mm-KEY
S3: RST#; SMD_6.1x3.65x2.5mm-KEY
S4: Download; SMD_6.1x3.65x2.5mm-KEY
U1: 1117-3.3V; SOT-223
U2: CH32V208W; QFN68_8x8
Y1: 32MHz; XT3225
Y2: 32768Hz; FC-135

Connections:
3V3: C2.1, J3.16, J3.20, J5.2, J5.4, P3.6, P4.1, P4.3, P4.5, R2.1
3V3S: D1.1, R2.2, R8.1, R9.1, R10.2, R16.1, R17.1, U1.2
+5V: F1.1, J1.A4, J1.B4, J3.22, J3.28, J5.5, J5.8, P1.1, P3.2, P3.4, P5.1, P6.9, P6.10
ANT: C17.2, L1.1, U2.51
BOOT0: R22.2, S4.2, U2.63
BOOT1: J4.34, R21.1, U2.28
CC1: J1.A5, R19.1
CC2: J1.B5, R18.1
ELED1: J3.7, P2.10
ELED2: J3.9, P2.11
ERXN: P2.6, R13.2
ERXP: P2.3, R14.2
ETXN: P2.2, R11.2
ETXP: P2.1, R12.2
GND: C1.2, C2.2, C3.1, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.2, E1.0, J1.0, J1.A1, J1.B1, J3.5, J3.6, J3.24, J3.26, J4.7, J4.38, J5.6, J5.7, J7.4, P1.0, P1.4, P3.1, P3.3, P3.5, P3.7, P5.0, P5.4, P6.5, P6.6, R1.1, R7.1, R15.1, R18.2, R19.2, S3.1, U1.1, U2.0, U2.5, U2.49, Y1.2, Y1.4
KEY: J3.12, S2.1
LED1: D3.2, J3.8
LED2: D4.2, J3.10
NRST: C15.2, J3.18, J5.3, S3.2, U2.8
NetC3_2: C3.2, P2.4, P2.5, R10.1
NetC16_2: C16.2, E1.1, L1.2
NetD1_2: D1.2, R1.2
NetD3_1: D3.1, R17.2
NetD4_1: D4.1, R16.2
NetF1_2: F1.2, S1.1
NetJ3_3: J3.3, R21.2
NetJ3_4: J3.4, R22.1
NetJ3_14: J3.14, J5.1
NetP2_8: P2.8, R7.2
NetP2_9: P2.9, R8.2
NetP2_12: P2.12, R9.2
NetR15_2: R15.2, S2.2
PA0: J3.32, J6.1, U2.14
PA1: J3.34, J6.2, U2.15
PA2: J3.36, J6.3, U2.16
PA3: J3.38, J6.4, U2.19
PA4: J3.40, J6.5, U2.20
PA5: J3.42, J6.6, U2.21
PA6: J3.41, U2.22
PA7: J3.39, U2.23
PA8: J4.23, J8.1, U2.43
PA9: J4.35, J8.7, P6.2, U2.44
PA10: J4.37, J8.8, P6.4, U2.45
PA11: J3.37, P1.2, U2.46
PA12: J3.35, P1.3, U2.47
PA13: J3.33, P6.3, U2.48
PA14: J3.31, P6.1, U2.52
PA15: J3.29, U2.53
PB0: J4.17, J7.9, U2.26
PB1: J4.19, J7.10, U2.27
PB3: J4.32, U2.58
PB4: J4.33, J8.6, U2.59
PB5: J4.30, U2.60
PB6: J1.A7, J1.B7, J4.31, J8.5, P5.2, U2.61
PB7: J1.A6, J1.B6, J4.29, J8.4, P5.3, U2.62
PB8: J4.27, J8.3, U2.64
PB9: J4.25, J8.2, U2.65
PB10: J4.1, J7.1, U2.29
PB11: J4.3, J7.2, U2.30
PB12: J4.15, J7.8, U2.35
PB13: J4.9, J7.5, U2.36
PB14: J4.11, J7.6, U2.37
PB15: J4.13, J7.7, U2.38
PC0: J4.2, U2.9
PC1: J4.4, U2.10
PC2: J4.6, U2.11
PC3: J4.8, U2.12
PC4: J4.10, U2.24
PC5: J4.12, U2.25
PC6: J4.14, R14.1, U2.39
PC7: J4.16, R13.1, U2.40
PC8: J4.18, R12.1, U2.41
PC9: J4.20, R11.1, U2.42
PC10: J4.22, U2.54
PC11: J4.24, U2.55
PC12: J4.26, U2.56
PC13: J4.28, U2.2
PC14: J3.11, R5.1
PC15: J3.13, R6.1
PD0: J3.15, R3.1
PD1: J3.17, R4.1
PD2: J3.19, U2.57
PD3: J3.21, U2.66
PD4: J3.23, U2.18
PD5: J3.25, U2.33
PD6: J3.27, U2.34
V5V: C1.1, S1.2, U1.3
VBAT: C6.1, J4.36, P4.6, U2.1
VDD: C4.1, C10.2, J3.1, J3.2, P3.8, P4.4, P6.7, P6.8, S4.1, U2.32, U2.68
VDDA: C18.1, J4.5, J7.3, R20.2, U2.13
VINTA: C7.1, U2.50
VIO: C5.2, C8.1, C9.1, P4.2, R20.1, U2.17, U2.31, U2.67
X32IN: C13.2, R5.2, U2.3, Y2.1
X32OUT: C14.2, R6.2, U2.4, Y2.2
XIN: R3.2, U2.6, Y1.1
XOUT: R4.2, U2.7, Y1.3

## KiCad design EVT/PUB/SCHPCB/CH32V203RBT6-R1/CH32V203RBT6-R1.kicad_pcb

Board: 2 copper layers, 74.0 x 85.6 mm, 74 parts (0 on the bottom side), 107 nets.

Parts:
C1, C3, C4, C7, C9, C10, C11, C21: 0.1uF; 0603_C
C2, C8: 22pF; 0603_C
C5, C6: 12pF; 0603_C
C12, C13: 10uF; 3216_C
C14: 1uF; 0603_C
C31, C32: NC(22pF); 0603_C
D2: BLUE; 0603+
D3: RED; 0603+
F2: 500mA; 0805
J2: Header 6X2; IDC12-2.54mm
J3, J4: Header 19X2; IDC38-2.54mm
J5, J8: Header 8; SIP8-2.54mm
J6: Header 6; SIP6-2.54MM
J7: Header 10; SIP10-2.54mm
LED1: LED1 blue; 0603+
LED2: LED2 blue; 0603+
P2: HR911105A
P6, P9: TYPE-C; TYPE-C-Receptacle-2.0
P7: USBFS; TYPE-C-Receptacle-2.0
PWR: POWER red; 0603+
R1, R2, R3, R13, R21, R28, R29, R30: 1K; 0603
R5, R14, R24: 10K; 0603
R7, R12, R15: 0Ω; 0603
R8, R9, R10, R11, R18, R25: NC(5.1K); 0603
R16, R22: 0; 0603
R17, R19: 100; 0603
R20, R34: 270; 0603
R27: 0Ω; 8P4R-0603
R32, R35: NC(0R); 0603
RT: Testpoint; TESTPOINT1
S1: RESET; KEYX
S2: USER; KEYX
S3: SW; SW1
S5: KEY; 贴片按键
U1: 1117-3.3V; SOT-223
U2: CH32V307R; LQFP64M_10X10
U3: CH32V305F; TSSOP20
Y1: 8MHz; XT3225
Y2: 32.768k; FC-135
Y3: NC(12M); XT3225

Connections:
5V_in: F2.1, P6.A4, P6.B4, P7.A4, P7.B4, P9.A4, P9.B4
+5V: C12.1, F2.2, J3.18, J3.24, J4.8, J5.5, J5.8, U1.3
BOOT0: R5.2, U2.60
BOOT1: J3.5, J4.38, U2.28
CLK: J2.2, J3.25, U2.49
CLK0: J2.1, R17.1
DIO: J2.4, J3.27, U2.46
DIO0: J2.3, R19.1
D_SWCLK: R17.2, U3.6, U3.15
D_SWDIO: R19.2, R30.1, U3.13
ELED1: J3.23, P2.10
ELED2: J3.17, P2.11
ERXN: J4.18, R27.3, U2.38
ERXN1: P2.6, R27.6
ERXP: J4.16, R27.4, U2.37
ERXP1: P2.3, R27.5
ETXN: J4.22, R27.1, U2.40
ETXN1: P2.2, R27.8
ETXP: J4.21, R27.2, U2.39
ETXP1: P2.1, R27.7
GND: C1.1, C2.1, C3.1, C4.1, C5.2, C6.2, C7.1, C8.1, C9.2, C10.2, C11.1, C12.2, C13.2, C14.1, C21.2, C31.1, C32.1, J2.5, J2.6, J3.7, J3.8, J3.19, J3.20, J3.21, J3.22, J4.7, J4.32, J5.6, J5.7, J7.4, P2.8, P6.0, P6.A1, P6.B1, P7.0, P7.A1, P7.B1, P9.0, P9.A1, P9.B1, PWR.2, R8.1, R9.1, R10.2, R11.2, R18.1, R21.1, R22.1, R25.1, S1.3, S2.3, S5.2, U1.1, U2.12, U2.18, U2.31, U2.63, U3.18, Y1.2, Y1.4, Y3.2, Y3.4
IAP: R14.1, S5.1, U3.10
KEY: J3.15, R24.1, S2.1
LED1: J3.11, LED1.2
LED2: J3.13, LED2.2
LED_CON: R13.1, U3.12
NRST: C11.2, J3.14, J5.3, S1.1, U2.7
NetC13_1: C13.1, S3.1, U1.2
NetD2_2: D2.2, R13.2
NetD3_2: D3.2, R21.2
NetJ3_6: J3.6, R5.1
NetJ3_10: J3.10, J5.1
NetLED1_1: LED1.1, R2.2
NetLED2_1: LED2.1, R3.2
NetP2_9: P2.9, R28.2
NetP2_12: P2.12, R29.2
NetP6_A5: P6.A5, R18.2
NetP6_B5: P6.B5, R25.2
NetP7_A5: P7.A5, R8.2
NetP7_B5: P7.B5, R9.2
NetP9_A5: P9.A5, R10.1
NetP9_B5: P9.B5, R11.1
NetPWR_1: PWR.1, R1.1
NetR16_2: R16.2, U2.48
NetR22_2: R22.2, U2.47
OSC_IN: C32.2, R32.2, Y3.1
OSC_OUT: C31.2, R35.2, Y3.3
PA0: J3.28, J6.1, U2.14
PA1: J3.30, J6.2, U2.15
PA2: J3.32, J6.3, U2.16
PA3: J3.34, J6.4, U2.17
PA4: J3.36, J6.5, U2.20
PA5: J3.38, J6.6, U2.21
PA6: J3.37, U2.22
PA7: J3.35, U2.23
PA8: J4.23, J8.1, U2.41
PA9: J2.10, J4.35, J8.7, U2.42
PA10: J2.12, J4.37, J8.8, U2.43
PA11: J3.31, P7.A7, P7.B7, U2.44
PA12: J3.29, P7.A6, P7.B6, U2.45
PA15: J3.26, U2.50
PB0: J4.17, J7.9, U2.26
PB1: J4.19, J7.10, U2.27
PB3: J4.36, U2.55
PB4: J4.33, J8.6, U2.56
PB5: J4.34, U2.57
PB6: J4.31, J8.5, P6.A7, P6.B7, U2.58
PB7: J4.29, J8.4, P6.A6, P6.B6, U2.59
PB8: J4.27, J8.3, U2.61
PB9: J4.25, J8.2, U2.62
PB10: J4.1, J7.1, U2.29
PB11: J4.3, J7.2, U2.30
PB12: J4.15, J7.8, U2.33
PB13: J4.9, J7.5, U2.34
PB14: J4.11, J7.6, U2.35
PB15: J4.13, J7.7, U2.36
PC0: J4.2, U2.8
PC1: J4.4, U2.9
PC2: J4.6, U2.10
PC3: J4.10, U2.11
PC4: J4.12, U2.24
PC5: J4.14, U2.25
PC6_305: R30.2, U3.9
PC10: J4.24, U2.51
PC11: J4.26, U2.52
PC12: J4.28, U2.53
PC13: J4.30, U2.2
PC14: C5.1, U2.3, Y2.1
PC15: C6.1, U2.4, Y2.2
PD0: C2.2, U2.5, Y1.1
PD0_305: R32.1, U3.19
PD1: C8.2, U2.6, Y1.3
PD1_305: R35.1, U3.20
PD2: J3.9, U2.54
RST0: J2.8, U3.11
RT: RT.1, U3.1
RX_OUT: J2.9, R20.1
TX_OUT: J2.11, R34.1
UART3_RX: R20.2, U3.4
UART3_TX: R34.2, U3.3
USB_N: P9.A7, P9.B7, U3.16
USB_P: P9.A6, P9.B6, U3.17
VBAT: C9.1, J3.33, U2.1
VCC: C14.2, C21.1, D2.1, D3.1, J2.7, J3.1, J3.2, J3.3, J3.4, J3.12, J3.16, J5.2, J5.4, P2.4, P2.5, R1.2, R2.1, R3.1, R7.1, R14.2, R24.2, R28.1, R29.1, S3.3, U3.14
VDD: C4.2, C7.2, R7.2, R12.2, R15.2, R16.1, U2.19
VDDA: C10.1, J4.5, J7.3, R12.1, U2.13
VIO: C1.2, C3.2, J4.20, R15.1, U2.32, U2.64

## KiCad design EVT/PUB/SCHPCB/CH32V203F6P6-R0/CH32V203F6P6-R0.kicad_pcb

Board: 2 copper layers, 38.0 x 55.0 mm, 29 parts (0 on the bottom side), 31 nets.

Parts:
C7, C8: 22pF; 0603_C
C11, C15, C18: 0.1uF; 0603_C
C12: 10uF; 3216_C
C13: 2.2uF; 0603_C
F1: 500mA; 0603
LED1: LED1 blue; 0603+
LED2: LED2 blue; 0603+
P1, P2: HEADER 6x2; IDC12-2.54mm
P4: 2HEAD; SIP2-2.54mm
P6: USB_A; USBAF
P7: TYPE-C; TYPE-C-Receptacle-2.0
PWR: POWER red; 0603+
R1, R2, R3: 1K; 0603
R4: NC(10K); 0603
R5: 4.7K; 0603
R7: 0Ω; 0603
R20, R21: NC(5.1K); 0603
S1: NRST; SMD_6.1x3.65x2.5mm-KEY
S2: SW; KEY2
U1: 6219P33M; SOT-23
U2: CH32V203F6; TSSOP20
Y1: 8M; XT_AT49

Connections:
+5V: P6.1, P7.A4, P7.B4, S2.1
BOOT0: P1.3, P1.4, U2.1
GND: C7.1, C8.1, C11.1, C12.2, C13.1, C15.2, C18.1, P1.1, P2.3, P2.4, P6.0, P6.4, P7.0, P7.A1, P7.B1, PWR.2, R5.2, R20.2, R21.2, S1.2, U1.1, U2.15, Y1.0
LED1: LED1.2, P4.1
LED2: LED2.2, P4.2
NRST: C11.2, P1.6, R4.1, S1.1, U2.4
NetC12_1: C12.1, F1.2, U1.3
NetF1_1: F1.1, S2.3
NetLED1_1: LED1.1, R2.2
NetLED2_1: LED2.1, R3.2
NetP1_2: P1.2, R5.1
NetP7_A5: P7.A5, R20.1
NetP7_B5: P7.B5, R21.1
NetPWR_1: PWR.1, R1.1
PA0: P1.5, U2.6
PA1: P1.8, U2.7
PA2: P1.7, U2.8
PA3: P1.10, U2.9
PA4: P1.9, U2.10
PA5: P2.12, U2.11
PA6: P2.11, U2.12
PA7: P2.10, U2.13
PA11: P2.7, P6.2, P7.A7, P7.B7, U2.17
PA12: P2.5, P6.3, P7.A6, P7.B6, U2.18
PA13: P2.6, U2.19
PA14: P2.8, U2.20
PB1: P2.9, U2.14
PD0: C7.2, U2.2, Y1.2
PD1: C8.2, U2.3, Y1.1
VCC: C13.2, C18.2, P1.12, P2.1, P2.2, R1.2, R2.1, R3.1, R4.2, R7.1, U1.2, U2.16
VDDA: C15.1, P1.11, R7.2, U2.5

## KiCad design EVT/PUB/SCHPCB/CH32V203C8T6-R1/CH32V203C8T6-R1.kicad_pcb

Board: 2 copper layers, 94.8 x 67.3 mm, 72 parts (0 on the bottom side), 72 nets.

Parts:
C1: NC(10uF); 3216
C2, C4, C11, C14, C15, C16, C17, C18: 0.1uF; 0603
C3, C24: NC(0.1uF); 0603
C5, C6: 12pF; 0603
C7, C8: 22pF; 0603
C12: 10uF; 3216
C13: 10uF; 0603
C20: NC(10uF); 3216_C
C21: NC(0.1uF); 0603_C
D1: POWER; 0603L
D2: LED1 blue; 0603L
D3: LED2 blue; 0603L
F1: 500mA; 0603
J5: Header 2; SIP2 - 40mil
P1, P2: Header 10X2; IDC20
P3: Header 2X2; HDR2X2
P4: Header 2; SIP2 - 40mil
P5: TF_自弹; TF_CARD
P6: Header 2; PORT2 4.5MM
P8: Header 5; SIP5 - 40mil
P9: HEADER 4x2; IDC8-2.54mm
P10: Header 4X2; IDC8
P12: TYPE-C; TYPE-C-Receptacle-2.0
P_HUSB0: USB_A; USBA-l
P_HUSB1: TYPE-C; TYPE-C-Receptacle-2.0
P_USB: TYPE-C; TYPE-C-Receptacle-2.0
R1, R2, R3: 1K; 0603
R4, R5, R6, R10: 10K; 0603
R7: 0Ω; 0603
R8, R9, R12, R13, R15: NC(10K); 0603
R11, R14, R16: NC(0Ω); 0603
R17: NC(120Ω); 0603
R20, R21, R22, R23, R24, R25: NC(5.1K); 0603
S1: KEY; 贴片按键
S2: SW; KEY2
TK1: KEY6; KEY68
TK2: KEY7; KEY68
U1: 1117-3.3V; SOT-223
U2: NC(24C02); SOP8
U3: CH32V203CxT; LQFP48
U4: W25Q16; 016 SO-8
U5: NC(CH340X); MSOP10
U6: NC(TJA1050); SOP8
Y1: 8M; 28
Y2: 32.768k; FC-135

Connections:
3V3: C1.1, C2.1, C3.2, C4.2, C13.1, C16.2, C17.2, C18.2, C21.1, P1.20, P2.2, P5.4, P9.1, P9.2, P10.2, P10.4, R1.2, R2.1, R3.1, R4.2, R7.1, R8.1, R9.1, R10.2, R12.2, R13.2, R15.1, U1.2, U2.8, U3.24, U3.36, U3.48, U4.3, U4.7, U4.8, U5.7, U5.10
5V: C12.1, C24.2, F1.2, P10.6, P10.8, U1.3, U6.3
+5V: C20.2, P8.1, P12.A4, P12.B4, P_HUSB0.1, P_HUSB1.A4, P_HUSB1.B4, P_USB.A4, P_USB.B4, S2.1
BOOT0: P3.3, U3.44
BOOT1: P1.13, P3.4, U3.20
CAN0H: P6.1, R17.1, U6.7
CAN0L: P6.2, R17.2, U6.6
DTR: P3.1, R5.1, U5.6
GND: C1.2, C2.2, C3.1, C4.1, C5.2, C6.2, C7.1, C8.1, C11.1, C12.2, C13.2, C14.2, C15.2, C16.1, C17.1, C18.1, C20.1, C21.2, C24.1, D1.2, P2.14, P5.6, P5.10, P8.5, P9.7, P9.8, P10.1, P10.3, P10.5, P10.7, P12.0, P12.A1, P12.B1, P_HUSB0.4, P_HUSB0.5, P_HUSB0.6, P_HUSB1.0, P_HUSB1.A1, P_HUSB1.B1, P_USB.0, P_USB.A1, P_USB.B1, R5.2, R6.2, R16.1, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, S1.3, U1.1, U2.1, U2.2, U2.3, U2.4, U2.7, U3.8, U3.23, U3.35, U3.47, U4.4, U5.3, U6.2, Y1.0
IIC_SCL: J5.2, R8.2, U2.6
IIC_SDA: J5.1, R9.2, U2.5
LED1: D2.2, P4.1
LED2: D3.2, P4.2
MCU_RXD: P9.6, U5.8
MCU_TXD: P9.4, U5.9
NRST: C11.2, P2.13, P8.4, R4.1, S1.1, U3.7, U5.4
NetD1_1: D1.1, R1.1
NetD2_1: D2.1, R2.2
NetD3_1: D3.1, R3.2
NetF1_1: F1.1, S2.2
NetP3_2: P3.2, R6.1
NetP5_1: P5.1, R12.1
NetP5_2: P5.2, R13.1, R14.1
NetP5_8: P5.8, R15.2
NetP12_A5: P12.A5, R25.1
NetP12_B5: P12.B5, R24.1
NetP_HUSB1_A5: P_HUSB1.A5, R20.1
NetP_HUSB1_B5: P_HUSB1.B5, R21.1
NetP_USB_A5: P_USB.A5, R22.1
NetP_USB_B5: P_USB.B5, R23.1
NetR10_1: R10.1, R11.1, U4.1
NetR16_2: R16.2, U6.8
PA0: P1.3, U3.10
PA1: P1.4, TK1.1, U3.11
PA2: P1.5, R11.2, TK2.1, U3.12
PA3: P1.6, R14.2, U3.13
PA4: P1.7, U3.14
PA5: P1.8, P5.5, U3.15, U4.6
PA6: P1.9, P5.7, U3.16, U4.2
PA7: P1.10, P5.3, U3.17, U4.5
PA8: P2.20, P5.9, U3.29
PA9: P2.19, P9.3, U3.30
PA10: P2.18, P9.5, U3.31
PA11: P2.17, P_USB.A7, P_USB.B7, U3.32
PA12: P2.16, P_USB.A6, P_USB.B6, U3.33
PA13: P2.15, P8.2, U3.34
PA14: P2.12, P8.3, U3.37
PA15: P2.11, U3.38
PB0: P1.11, U3.18
PB1: P1.12, U3.19
PB3: P2.10, U3.39
PB4: P2.9, U3.40
PB5: P2.8, U3.41
PB6: P2.7, P_HUSB0.2, P_HUSB1.A7, P_HUSB1.B7, U3.42
PB7: P2.6, P_HUSB0.3, P_HUSB1.A6, P_HUSB1.B6, U3.43
PB8: P2.5, U3.45, U6.4
PB9: P2.3, U3.46, U6.1
PB10: P1.14, U3.21
PB11: P1.15, U3.22
PB12: P1.16, U3.25
PB13: P1.17, U3.26
PB14: P1.18, U3.27
PB15: P1.19, U3.28
PC13: P2.4, U3.2
PC14: C5.1, U3.3, Y2.1
PC15: C6.1, U3.4, Y2.2
PD0: C7.2, P1.1, U3.5, Y1.2
PD1: C8.2, P1.2, U3.6, Y1.1
UD+: P12.A6, P12.B6, U5.1
UD-: P12.A7, P12.B7, U5.2
VBAT: C14.1, P2.1, U3.1
VDDA: C15.1, R7.2, U3.9
